v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {chip_top — IHP SG13G2 pad ring (32 pads @ 150 um pitch, mirrors src/chip_top.v)} -1050 -1780 0 0 0.6 0.6 {}
T {Koen Van Caekenberghe (koen.vancaekenberghe@chipdesign.be), ChipDesign B.V., 07.2026 — Apache-2.0} -1050 -1720 0 0 0.35 0.35 {}
T {corner and filler cells are physical-only (no schematic view); ring rails VDD/VSS/IOVDD/IOVSS connect by abutment in layout} -1050 -1670 0 0 0.3 0.3 {}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 0 -1200 0 0 {name=sg13g2_IOPad_dout[0].sg13g2_IOPad_io_dout}
C {devices/lab_pin.sym} 30.0 -1540.0 0 0 {name=l1_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 40.0 -1530.0 0 0 {name=l1_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 50.0 -1520.0 0 0 {name=l1_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 60.0 -1510.0 0 0 {name=l1_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 200.0 -1550.0 0 0 {name=l1_c2p sig_type=std_logic lab=dout_o[0]}
C {devices/lab_pin.sym} 110.0 -1300.0 0 0 {name=l1_padpin sig_type=std_logic lab=dout_PAD[0]}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 300 -1200 0 0 {name=sg13g2_IOPad_dout[1].sg13g2_IOPad_io_dout}
C {devices/lab_pin.sym} 330.0 -1540.0 0 0 {name=l2_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 340.0 -1530.0 0 0 {name=l2_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 350.0 -1520.0 0 0 {name=l2_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 360.0 -1510.0 0 0 {name=l2_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 500.0 -1550.0 0 0 {name=l2_c2p sig_type=std_logic lab=dout_o[1]}
C {devices/lab_pin.sym} 410.0 -1300.0 0 0 {name=l2_padpin sig_type=std_logic lab=dout_PAD[1]}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 600 -1200 0 0 {name=sg13g2_IOPad_dout[2].sg13g2_IOPad_io_dout}
C {devices/lab_pin.sym} 630.0 -1540.0 0 0 {name=l3_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 640.0 -1530.0 0 0 {name=l3_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 650.0 -1520.0 0 0 {name=l3_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 660.0 -1510.0 0 0 {name=l3_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 800.0 -1550.0 0 0 {name=l3_c2p sig_type=std_logic lab=dout_o[2]}
C {devices/lab_pin.sym} 710.0 -1300.0 0 0 {name=l3_padpin sig_type=std_logic lab=dout_PAD[2]}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 900 -1200 0 0 {name=sg13g2_IOPad_dout[3].sg13g2_IOPad_io_dout}
C {devices/lab_pin.sym} 930.0 -1540.0 0 0 {name=l4_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 940.0 -1530.0 0 0 {name=l4_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 950.0 -1520.0 0 0 {name=l4_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 960.0 -1510.0 0 0 {name=l4_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 1100.0 -1550.0 0 0 {name=l4_c2p sig_type=std_logic lab=dout_o[3]}
C {devices/lab_pin.sym} 1010.0 -1300.0 0 0 {name=l4_padpin sig_type=std_logic lab=dout_PAD[3]}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 1200 -1200 0 0 {name=sg13g2_IOPad_dout[4].sg13g2_IOPad_io_dout}
C {devices/lab_pin.sym} 1230.0 -1540.0 0 0 {name=l5_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1240.0 -1530.0 0 0 {name=l5_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1250.0 -1520.0 0 0 {name=l5_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 1260.0 -1510.0 0 0 {name=l5_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 1400.0 -1550.0 0 0 {name=l5_c2p sig_type=std_logic lab=dout_o[4]}
C {devices/lab_pin.sym} 1310.0 -1300.0 0 0 {name=l5_padpin sig_type=std_logic lab=dout_PAD[4]}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 1500 -1200 0 0 {name=sg13g2_IOPad_dout[5].sg13g2_IOPad_io_dout}
C {devices/lab_pin.sym} 1530.0 -1540.0 0 0 {name=l6_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1540.0 -1530.0 0 0 {name=l6_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1550.0 -1520.0 0 0 {name=l6_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 1560.0 -1510.0 0 0 {name=l6_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 1700.0 -1550.0 0 0 {name=l6_c2p sig_type=std_logic lab=dout_o[5]}
C {devices/lab_pin.sym} 1610.0 -1300.0 0 0 {name=l6_padpin sig_type=std_logic lab=dout_PAD[5]}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 1800 -1200 0 0 {name=sg13g2_IOPad_dout[6].sg13g2_IOPad_io_dout}
C {devices/lab_pin.sym} 1830.0 -1540.0 0 0 {name=l7_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1840.0 -1530.0 0 0 {name=l7_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1850.0 -1520.0 0 0 {name=l7_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 1860.0 -1510.0 0 0 {name=l7_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 2000.0 -1550.0 0 0 {name=l7_c2p sig_type=std_logic lab=dout_o[6]}
C {devices/lab_pin.sym} 1910.0 -1300.0 0 0 {name=l7_padpin sig_type=std_logic lab=dout_PAD[6]}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 2100 -1200 0 0 {name=sg13g2_IOPad_dout[7].sg13g2_IOPad_io_dout}
C {devices/lab_pin.sym} 2130.0 -1540.0 0 0 {name=l8_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2140.0 -1530.0 0 0 {name=l8_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2150.0 -1520.0 0 0 {name=l8_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 2160.0 -1510.0 0 0 {name=l8_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 2300.0 -1550.0 0 0 {name=l8_c2p sig_type=std_logic lab=dout_o[7]}
C {devices/lab_pin.sym} 2210.0 -1300.0 0 0 {name=l8_padpin sig_type=std_logic lab=dout_PAD[7]}
C {sg13g2_io/sg13g2_IOPadIn.sym} 0 1500 0 0 {name=sg13g2_IOPad_io_clk}
C {devices/lab_pin.sym} 30.0 1160.0 0 0 {name=l9_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 40.0 1170.0 0 0 {name=l9_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 50.0 1180.0 0 0 {name=l9_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 60.0 1190.0 0 0 {name=l9_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 200.0 1150.0 0 0 {name=l9_p2c sig_type=std_logic lab=clk_i}
C {devices/lab_pin.sym} 110.0 1400.0 0 0 {name=l9_padpin sig_type=std_logic lab=clk_PAD}
C {sg13g2_io/sg13g2_IOPadIn.sym} 300 1500 0 0 {name=sg13g2_IOPad_io_rst}
C {devices/lab_pin.sym} 330.0 1160.0 0 0 {name=l10_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 340.0 1170.0 0 0 {name=l10_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 350.0 1180.0 0 0 {name=l10_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 360.0 1190.0 0 0 {name=l10_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 500.0 1150.0 0 0 {name=l10_p2c sig_type=std_logic lab=rst_n_i}
C {devices/lab_pin.sym} 410.0 1400.0 0 0 {name=l10_padpin sig_type=std_logic lab=rst_n_PAD}
C {sg13g2_io/sg13g2_IOPadIn.sym} 600 1500 0 0 {name=sg13g2_IOPad_din_lo[0].sg13g2_IOPad_io_din}
C {devices/lab_pin.sym} 630.0 1160.0 0 0 {name=l11_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 640.0 1170.0 0 0 {name=l11_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 650.0 1180.0 0 0 {name=l11_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 660.0 1190.0 0 0 {name=l11_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 800.0 1150.0 0 0 {name=l11_p2c sig_type=std_logic lab=din_i[0]}
C {devices/lab_pin.sym} 710.0 1400.0 0 0 {name=l11_padpin sig_type=std_logic lab=din_lo_PAD[0]}
C {sg13g2_io/sg13g2_IOPadIn.sym} 900 1500 0 0 {name=sg13g2_IOPad_din_lo[1].sg13g2_IOPad_io_din}
C {devices/lab_pin.sym} 930.0 1160.0 0 0 {name=l12_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 940.0 1170.0 0 0 {name=l12_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 950.0 1180.0 0 0 {name=l12_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 960.0 1190.0 0 0 {name=l12_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 1100.0 1150.0 0 0 {name=l12_p2c sig_type=std_logic lab=din_i[1]}
C {devices/lab_pin.sym} 1010.0 1400.0 0 0 {name=l12_padpin sig_type=std_logic lab=din_lo_PAD[1]}
C {sg13g2_io/sg13g2_IOPadIn.sym} 1200 1500 0 0 {name=sg13g2_IOPad_din_lo[2].sg13g2_IOPad_io_din}
C {devices/lab_pin.sym} 1230.0 1160.0 0 0 {name=l13_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1240.0 1170.0 0 0 {name=l13_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1250.0 1180.0 0 0 {name=l13_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 1260.0 1190.0 0 0 {name=l13_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 1400.0 1150.0 0 0 {name=l13_p2c sig_type=std_logic lab=din_i[2]}
C {devices/lab_pin.sym} 1310.0 1400.0 0 0 {name=l13_padpin sig_type=std_logic lab=din_lo_PAD[2]}
C {sg13g2_io/sg13g2_IOPadIn.sym} 1500 1500 0 0 {name=sg13g2_IOPad_din_lo[3].sg13g2_IOPad_io_din}
C {devices/lab_pin.sym} 1530.0 1160.0 0 0 {name=l14_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1540.0 1170.0 0 0 {name=l14_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1550.0 1180.0 0 0 {name=l14_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 1560.0 1190.0 0 0 {name=l14_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 1700.0 1150.0 0 0 {name=l14_p2c sig_type=std_logic lab=din_i[3]}
C {devices/lab_pin.sym} 1610.0 1400.0 0 0 {name=l14_padpin sig_type=std_logic lab=din_lo_PAD[3]}
C {sg13g2_io/sg13g2_IOPadIn.sym} 1800 1500 0 0 {name=sg13g2_IOPad_din_lo[4].sg13g2_IOPad_io_din}
C {devices/lab_pin.sym} 1830.0 1160.0 0 0 {name=l15_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1840.0 1170.0 0 0 {name=l15_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1850.0 1180.0 0 0 {name=l15_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 1860.0 1190.0 0 0 {name=l15_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 2000.0 1150.0 0 0 {name=l15_p2c sig_type=std_logic lab=din_i[4]}
C {devices/lab_pin.sym} 1910.0 1400.0 0 0 {name=l15_padpin sig_type=std_logic lab=din_lo_PAD[4]}
C {sg13g2_io/sg13g2_IOPadIn.sym} 2100 1500 0 0 {name=sg13g2_IOPad_din_lo[5].sg13g2_IOPad_io_din}
C {devices/lab_pin.sym} 2130.0 1160.0 0 0 {name=l16_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2140.0 1170.0 0 0 {name=l16_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2150.0 1180.0 0 0 {name=l16_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 2160.0 1190.0 0 0 {name=l16_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 2300.0 1150.0 0 0 {name=l16_p2c sig_type=std_logic lab=din_i[5]}
C {devices/lab_pin.sym} 2210.0 1400.0 0 0 {name=l16_padpin sig_type=std_logic lab=din_lo_PAD[5]}
C {sg13g2_io/sg13g2_IOPadIOVdd.sym} -1050 -850 0 0 {name=sg13g2_IOPad_iovdd_w}
C {devices/lab_pin.sym} -1020.0 -1190.0 0 0 {name=l17_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1010.0 -1180.0 0 0 {name=l17_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -1000.0 -1170.0 0 0 {name=l17_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} -990.0 -1160.0 0 0 {name=l17_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} -940.0 -950.0 0 0 {name=l17_padpin sig_type=std_logic lab=IOVDD}
C {sg13g2_io/sg13g2_IOPadIOVss.sym} -1050 -350 0 0 {name=sg13g2_IOPad_iovss_w}
C {devices/lab_pin.sym} -1020.0 -690.0 0 0 {name=l18_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1010.0 -680.0 0 0 {name=l18_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -1000.0 -670.0 0 0 {name=l18_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} -990.0 -660.0 0 0 {name=l18_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} -940.0 -450.0 0 0 {name=l18_padpin sig_type=std_logic lab=IOVSS}
C {sg13g2_io/sg13g2_IOPadIn.sym} -1050 150 0 0 {name=sg13g2_IOPad_din_hi[0].sg13g2_IOPad_io_din}
C {devices/lab_pin.sym} -1020.0 -190.0 0 0 {name=l19_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1010.0 -180.0 0 0 {name=l19_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -1000.0 -170.0 0 0 {name=l19_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} -990.0 -160.0 0 0 {name=l19_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} -850.0 -200.0 0 0 {name=l19_p2c sig_type=std_logic lab=din_i[6]}
C {devices/lab_pin.sym} -940.0 50.0 0 0 {name=l19_padpin sig_type=std_logic lab=din_hi_PAD[0]}
C {sg13g2_io/sg13g2_IOPadIn.sym} -1050 650 0 0 {name=sg13g2_IOPad_din_hi[1].sg13g2_IOPad_io_din}
C {devices/lab_pin.sym} -1020.0 310.0 0 0 {name=l20_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1010.0 320.0 0 0 {name=l20_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -1000.0 330.0 0 0 {name=l20_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} -990.0 340.0 0 0 {name=l20_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} -850.0 300.0 0 0 {name=l20_p2c sig_type=std_logic lab=din_i[7]}
C {devices/lab_pin.sym} -940.0 550.0 0 0 {name=l20_padpin sig_type=std_logic lab=din_hi_PAD[1]}
C {sg13g2_io/sg13g2_IOPadIn.sym} -700 -850 0 0 {name=sg13g2_IOPad_io_start}
C {devices/lab_pin.sym} -670.0 -1190.0 0 0 {name=l21_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -660.0 -1180.0 0 0 {name=l21_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -650.0 -1170.0 0 0 {name=l21_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} -640.0 -1160.0 0 0 {name=l21_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} -500.0 -1200.0 0 0 {name=l21_p2c sig_type=std_logic lab=start_i}
C {devices/lab_pin.sym} -590.0 -950.0 0 0 {name=l21_padpin sig_type=std_logic lab=start_PAD}
C {sg13g2_io/sg13g2_IOPadIn.sym} -700 -350 0 0 {name=sg13g2_IOPad_io_mode}
C {devices/lab_pin.sym} -670.0 -690.0 0 0 {name=l22_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -660.0 -680.0 0 0 {name=l22_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -650.0 -670.0 0 0 {name=l22_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} -640.0 -660.0 0 0 {name=l22_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} -500.0 -700.0 0 0 {name=l22_p2c sig_type=std_logic lab=mode_i}
C {devices/lab_pin.sym} -590.0 -450.0 0 0 {name=l22_padpin sig_type=std_logic lab=mode_PAD}
C {sg13g2_io/sg13g2_IOPadVdd.sym} -700 150 0 0 {name=sg13g2_IOPad_vdd_w}
C {devices/lab_pin.sym} -670.0 -190.0 0 0 {name=l23_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -660.0 -180.0 0 0 {name=l23_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -650.0 -170.0 0 0 {name=l23_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} -640.0 -160.0 0 0 {name=l23_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} -590.0 50.0 0 0 {name=l23_padpin sig_type=std_logic lab=VDD}
C {sg13g2_io/sg13g2_IOPadVss.sym} -700 650 0 0 {name=sg13g2_IOPad_vss_w}
C {devices/lab_pin.sym} -670.0 310.0 0 0 {name=l24_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -660.0 320.0 0 0 {name=l24_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -650.0 330.0 0 0 {name=l24_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} -640.0 340.0 0 0 {name=l24_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} -590.0 550.0 0 0 {name=l24_padpin sig_type=std_logic lab=VSS}
C {sg13g2_io/sg13g2_IOPadIOVdd.sym} 2450 -850 0 0 {name=sg13g2_IOPad_iovdd_e}
C {devices/lab_pin.sym} 2480.0 -1190.0 0 0 {name=l25_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2490.0 -1180.0 0 0 {name=l25_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2500.0 -1170.0 0 0 {name=l25_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 2510.0 -1160.0 0 0 {name=l25_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 2560.0 -950.0 0 0 {name=l25_padpin sig_type=std_logic lab=IOVDD}
C {sg13g2_io/sg13g2_IOPadIOVss.sym} 2450 -350 0 0 {name=sg13g2_IOPad_iovss_e}
C {devices/lab_pin.sym} 2480.0 -690.0 0 0 {name=l26_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2490.0 -680.0 0 0 {name=l26_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2500.0 -670.0 0 0 {name=l26_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 2510.0 -660.0 0 0 {name=l26_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 2560.0 -450.0 0 0 {name=l26_padpin sig_type=std_logic lab=IOVSS}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 2450 150 0 0 {name=sg13g2_IOPad_io_done}
C {devices/lab_pin.sym} 2480.0 -190.0 0 0 {name=l27_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2490.0 -180.0 0 0 {name=l27_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2500.0 -170.0 0 0 {name=l27_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 2510.0 -160.0 0 0 {name=l27_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 2650.0 -200.0 0 0 {name=l27_c2p sig_type=std_logic lab=done_o}
C {devices/lab_pin.sym} 2560.0 50.0 0 0 {name=l27_padpin sig_type=std_logic lab=done_PAD}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 2450 650 0 0 {name=sg13g2_IOPad_io_busy}
C {devices/lab_pin.sym} 2480.0 310.0 0 0 {name=l28_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2490.0 320.0 0 0 {name=l28_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2500.0 330.0 0 0 {name=l28_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 2510.0 340.0 0 0 {name=l28_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 2650.0 300.0 0 0 {name=l28_c2p sig_type=std_logic lab=busy_o}
C {devices/lab_pin.sym} 2560.0 550.0 0 0 {name=l28_padpin sig_type=std_logic lab=busy_PAD}
C {sg13g2_io/sg13g2_IOPadOut30mA.sym} 2800 -850 0 0 {name=sg13g2_IOPad_io_irq}
C {devices/lab_pin.sym} 2830.0 -1190.0 0 0 {name=l29_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2840.0 -1180.0 0 0 {name=l29_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2850.0 -1170.0 0 0 {name=l29_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 2860.0 -1160.0 0 0 {name=l29_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 3000.0 -1200.0 0 0 {name=l29_c2p sig_type=std_logic lab=irq_o}
C {devices/lab_pin.sym} 2910.0 -950.0 0 0 {name=l29_padpin sig_type=std_logic lab=irq_PAD}
C {sg13g2_io/sg13g2_IOPadInOut30mA.sym} 2800 -350 0 0 {name=sg13g2_IOPad_io_gpio}
C {devices/lab_pin.sym} 2890.0 -690.0 0 0 {name=l30_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2900.0 -680.0 0 0 {name=l30_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2910.0 -670.0 0 0 {name=l30_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 2920.0 -660.0 0 0 {name=l30_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 2810.0 -710.0 0 0 {name=l30_p2c sig_type=std_logic lab=gpio_in}
C {devices/lab_pin.sym} 3000.0 -700.0 0 0 {name=l30_c2p sig_type=std_logic lab=gpio_out}
C {devices/lab_pin.sym} 2990.0 -710.0 0 0 {name=l30_c2p_en sig_type=std_logic lab=gpio_oe}
C {devices/lab_pin.sym} 2910.0 -450.0 0 0 {name=l30_padpin sig_type=std_logic lab=gpio_PAD}
C {sg13g2_io/sg13g2_IOPadVdd.sym} 2800 150 0 0 {name=sg13g2_IOPad_vdd_e}
C {devices/lab_pin.sym} 2830.0 -190.0 0 0 {name=l31_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2840.0 -180.0 0 0 {name=l31_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2850.0 -170.0 0 0 {name=l31_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 2860.0 -160.0 0 0 {name=l31_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 2910.0 50.0 0 0 {name=l31_padpin sig_type=std_logic lab=VDD}
C {sg13g2_io/sg13g2_IOPadVss.sym} 2800 650 0 0 {name=sg13g2_IOPad_vss_e}
C {devices/lab_pin.sym} 2830.0 310.0 0 0 {name=l32_vss sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2840.0 320.0 0 0 {name=l32_vdd sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2850.0 330.0 0 0 {name=l32_iovss sig_type=std_logic lab=IOVSS}
C {devices/lab_pin.sym} 2860.0 340.0 0 0 {name=l32_iovdd sig_type=std_logic lab=IOVDD}
C {devices/lab_pin.sym} 2910.0 550.0 0 0 {name=l32_padpin sig_type=std_logic lab=VSS}
B 4 800 -420 1300 140 {}
T {demo_core} 950.0 -470 0 0 0.5 0.5 {}
T {core} 1010.0 -140.0 0 0 0.4 0.4 {}
L 4 760 -380 800 -380 {}
C {devices/lab_pin.sym} 760 -380 0 0 {name=cl0 sig_type=std_logic lab=clk_i}
L 4 760 -340 800 -340 {}
C {devices/lab_pin.sym} 760 -340 0 0 {name=cl1 sig_type=std_logic lab=rst_n_i}
L 4 760 -300 800 -300 {}
C {devices/lab_pin.sym} 760 -300 0 0 {name=cl2 sig_type=std_logic lab=start_i}
L 4 760 -260 800 -260 {}
C {devices/lab_pin.sym} 760 -260 0 0 {name=cl3 sig_type=std_logic lab=mode_i}
L 4 760 -220 800 -220 {}
C {devices/lab_pin.sym} 760 -220 0 0 {name=cl4 sig_type=std_logic lab=din_i[0]}
L 4 760 -180 800 -180 {}
C {devices/lab_pin.sym} 760 -180 0 0 {name=cl5 sig_type=std_logic lab=din_i[1]}
L 4 760 -140 800 -140 {}
C {devices/lab_pin.sym} 760 -140 0 0 {name=cl6 sig_type=std_logic lab=din_i[2]}
L 4 760 -100 800 -100 {}
C {devices/lab_pin.sym} 760 -100 0 0 {name=cl7 sig_type=std_logic lab=din_i[3]}
L 4 760 -60 800 -60 {}
C {devices/lab_pin.sym} 760 -60 0 0 {name=cl8 sig_type=std_logic lab=din_i[4]}
L 4 760 -20 800 -20 {}
C {devices/lab_pin.sym} 760 -20 0 0 {name=cl9 sig_type=std_logic lab=din_i[5]}
L 4 760 20 800 20 {}
C {devices/lab_pin.sym} 760 20 0 0 {name=cl10 sig_type=std_logic lab=din_i[6]}
L 4 760 60 800 60 {}
C {devices/lab_pin.sym} 760 60 0 0 {name=cl11 sig_type=std_logic lab=din_i[7]}
L 4 760 100 800 100 {}
C {devices/lab_pin.sym} 760 100 0 0 {name=cl12 sig_type=std_logic lab=gpio_in}
L 4 1300 -380 1340 -380 {}
C {devices/lab_pin.sym} 1340 -380 0 1 {name=cr0 sig_type=std_logic lab=dout_o[0]}
L 4 1300 -340 1340 -340 {}
C {devices/lab_pin.sym} 1340 -340 0 1 {name=cr1 sig_type=std_logic lab=dout_o[1]}
L 4 1300 -300 1340 -300 {}
C {devices/lab_pin.sym} 1340 -300 0 1 {name=cr2 sig_type=std_logic lab=dout_o[2]}
L 4 1300 -260 1340 -260 {}
C {devices/lab_pin.sym} 1340 -260 0 1 {name=cr3 sig_type=std_logic lab=dout_o[3]}
L 4 1300 -220 1340 -220 {}
C {devices/lab_pin.sym} 1340 -220 0 1 {name=cr4 sig_type=std_logic lab=dout_o[4]}
L 4 1300 -180 1340 -180 {}
C {devices/lab_pin.sym} 1340 -180 0 1 {name=cr5 sig_type=std_logic lab=dout_o[5]}
L 4 1300 -140 1340 -140 {}
C {devices/lab_pin.sym} 1340 -140 0 1 {name=cr6 sig_type=std_logic lab=dout_o[6]}
L 4 1300 -100 1340 -100 {}
C {devices/lab_pin.sym} 1340 -100 0 1 {name=cr7 sig_type=std_logic lab=dout_o[7]}
L 4 1300 -60 1340 -60 {}
C {devices/lab_pin.sym} 1340 -60 0 1 {name=cr8 sig_type=std_logic lab=done_o}
L 4 1300 -20 1340 -20 {}
C {devices/lab_pin.sym} 1340 -20 0 1 {name=cr9 sig_type=std_logic lab=busy_o}
L 4 1300 20 1340 20 {}
C {devices/lab_pin.sym} 1340 20 0 1 {name=cr10 sig_type=std_logic lab=irq_o}
L 4 1300 60 1340 60 {}
C {devices/lab_pin.sym} 1340 60 0 1 {name=cr11 sig_type=std_logic lab=gpio_out}
L 4 1300 100 1340 100 {}
C {devices/lab_pin.sym} 1340 100 0 1 {name=cr12 sig_type=std_logic lab=gpio_oe}
